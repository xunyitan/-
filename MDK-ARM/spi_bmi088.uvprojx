# Keil uVision project spi_bmi088.uvprojx, settings and files
target spi_bmi088 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi_bmi088 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../bsp/boards;../bsp/Algorithm;../bsp/Task;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../bsp/IMUS;..\bsp\BMI088;..\bsp\BMI088\inc
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c crc.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group boards
    ../bsp/boards/: can_Peripheral.c can_Peripheral.h buzzer_Peripheral.c djl_driver.c djl_driver.h Sys.c Sys.h lazer.c lazer.h referee.c referee.h dm_driver.c dm_driver.h dwt.c dwt.h
    ../bsp/Algorithm/: buzzer_Peripheral.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Algorithm
    ../bsp/Algorithm/: Can_receive.c Can_receive.h pid.c pid.h filter.c filter.h dbus_receive.c dbus_receive.h judge_and_debug.c judge_and_debug.h Squarewave.c Squarewave.h SCAP.c SCAP.h Ending.txt Sliding_Mode.c Sliding_Mode.h judge_sys.c judge_sys.h Gimbal_FindingMode.c Gimbal_FindingMode.h RLS.c RLS.h matrix.c matrix.h CRC8_CRC16.c CRC8_CRC16.h fifo.c fifo.h
  group Task
    ../bsp/Task/: ChassisTask.c ChassisTask.h CanTask.c CanTask.h Gimbal6020.c Gimbal6020.h ImuTask.c ImuTask.h ShootTask.c ShootTask.h Tim1Task.c Tim1Task.h RC_ProtectionTask.c RC_ProtectionTask.h Powercontrol.c Powercontrol.h HeatControlTask.c HeatControlTask.h refereetask.c refereetask.h VisionSendTask.c VisionSendTask.h PersonalUITask.c PersonalUITask.h
  group IMUS
    ../bsp/IMUS/: mahony.c mahony.h EKF.c EKF.h kalman_filter.c kalman_filter.h
  group BMI088
    ../bsp/BMI088/: BMI088driver.c BMI088Middleware.c
    ../bsp/BMI088/inc/: BMI088driver.h BMI088Middleware.h BMI088reg.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2
